# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\NET\HMAC\inc;.\hardware\LCD
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c
  group hardware
    ./hardware/src/: delay.c usart.c led.c button_led.c DS18B20.c relay.c tds.c BH1750.c BH1750_IIC.c PWM.c
    ./hardware/LCD/: lcd.c lcd_init.c
  group user
    ./user/: main.c
  group OneNET
    ./NET/onenet/src/: onenet.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
  group HMAC
    ./NET/HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
software components: CMSIS:CORE 4.3.0
